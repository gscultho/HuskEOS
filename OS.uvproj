# Keil uVision project OS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: huskieOS
  c flags: Optim=1
  c include: .\huskEOS\ASM;.\huskEOS\Global\Header;.\huskEOS\Mailbox\Header;.\huskEOS\Mailbox\Source;.\huskEOS\Schedule\Header;.\huskEOS\Schedule\Source;.\huskEOS\Queue\Header;.\huskEOS\Queue\Source;.\huskEOS\Semaphore\Header;.\huskEOS\Semaphore\Source;.\huskEOS\Flags\Header;.\huskEOS\Flags\Source;.\huskEOS\OS_CPU_Interface\Source;.\huskEOS\OS_CPU_Interface\ASM;.\huskEOS\OS_CPU_Interface\Header
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group OS
    ./huskEOS/Schedule/Header/: sch.h sch_internal_IF.h
    ./huskEOS/Schedule/Source/: sch.c
    ./huskEOS/Mailbox/Header/: mailbox.h mbox_internal_IF.h
    ./huskEOS/Mailbox/Source/: mailbox.c
    ./huskEOS/Queue/Header/: queue.h queue_internal_IF.h
    ./huskEOS/Queue/Source/: queue.c
    ./huskEOS/Semaphore/Header/: semaphore.h semaphore_internal_IF.h
    ./huskEOS/Semaphore/Source/: semaphore.c
    ./huskEOS/Flags/Header/: flags.h flags_internal_IF.h
    ./huskEOS/Flags/Source/: flags.c
    ./huskEOS/Global/Header/: rtos_cfg.h
    ./huskEOS/OS_CPU_Interface/ASM/: taskSwitch.s
    ./huskEOS/OS_CPU_Interface/Header/: cpu_defs.h cpu_os_interface.h
    ./huskEOS/OS_CPU_Interface/Source/: cpu_os_interface.c
  group Startup
    ./App/Startup/ASM/: startup.s
