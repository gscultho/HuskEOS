# Keil uVision project OS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: huskieOS
  c flags: Optim=1
  c include: .\..\huskEOS\ASM;.\..\huskEOS\Global\Header;.\..\huskEOS\Mailbox\Header;.\..\huskEOS\Mailbox\Source;.\..\huskEOS\Schedule\Header;.\..\huskEOS\Schedule\Source;.\..\huskEOS\Queue\Header;.\..\huskEOS\Queue\Source;.\..\huskEOS\Semaphore\Header;.\..\huskEOS\Semaphore\Source;.\..\huskEOS\Flags\Header;.\..\huskEOS\Flags\Source;.\..\huskEOS\OS_CPU_Interface\Source;.\..\huskEOS\OS_CPU_Interface\ASM;.\..\huskEOS\OS_CPU_Interface\Header;.\..\huskEOS\List_Manager\Header;.\..\huskEOS\List_Manager\Source;.\..\huskEOS\Mutex\Header;.\..\huskEOS\Mutex\Source;.\..\App\Source;.\..\App\driverlib;.\..\App\inc;.\..\App\utils
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  group OS
    ./huskEOS/Global/Header/: rtos_cfg.h
    ./huskEOS/Schedule/Header/: sch.h sch_internal_IF.h
    ./huskEOS/Schedule/Source/: sch.c
    ./huskEOS/Mailbox/Header/: mailbox.h mbox_internal_IF.h
    ./huskEOS/Mailbox/Source/: mailbox.c
    ./huskEOS/Queue/Header/: queue.h queue_internal_IF.h
    ./huskEOS/Queue/Source/: queue.c
    ./huskEOS/Semaphore/Header/: semaphore.h semaphore_internal_IF.h
    ./huskEOS/Semaphore/Source/: semaphore.c
    ./huskEOS/Flags/Header/: flags.h flags_internal_IF.h
    ./huskEOS/Flags/Source/: flags.c
    ./huskEOS/OS_CPU_Interface/Header/: cpu_os_interface.h cpu_defs.h
    ./huskEOS/OS_CPU_Interface/Source/: cpu_os_interface.c
    ./huskEOS/OS_CPU_Interface/ASM/: taskSwitch.s
    ./huskEOS/Mutex/Header/: mutex.h mutex_internal_IF.h
    ./huskEOS/Mutex/Source/: mutex.c
    ./huskEOS/List_Manager/Header/: listMgr_internal.h
    ./huskEOS/List_Manager/Source/: listMgr_internal.c
  group Startup
    ./App/Startup/ASM/: startup.s
  group App
    ./App/Source/: app.c
    ./App/utils/: uartstdio.c
  group Library
    ./App/driverlib/rvmdk/: driverlib.lib
